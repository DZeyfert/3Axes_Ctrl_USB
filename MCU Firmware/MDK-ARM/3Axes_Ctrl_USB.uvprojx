# Keil uVision project 3Axes_Ctrl_USB.uvprojx, settings and files
target 3Axes_Ctrl_USB (6190000::V6.19::ARMCLANG)
  device: STM32F446VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 3Axes_Ctrl_USB +hex
  BeforeMake: ..\Bin\purge.bat
  AfterMake: fromelf --bin --output ..\Bin\3Axes_Ctrl_USB.bin Obj\3Axes_Ctrl_USB.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F446xx
  c include: ..\CMSIS\Include;..\CMSIS\Device\ST\STM32F4xx\Include;..\Code;..\Drivers;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;..\USB\STM32_USB_Device_Library\Core\Inc;..\USB\STM32_USB_Device_Library\Class\CDC\Inc;..\USB\App;..\USB\Target
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Code
    ../Code/: main.c control.c motor.c pins.c timer.c stm32f4xx_it.c
    ../Drivers/: stm32f4xx_hal_msp.c
  group Drivers/HAL
    ../Drivers/: startup_stm32f446xx.s system_stm32f4xx.c
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group USB/App_Target
    ../USB/Target/: usbd_conf.c
    ../USB/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group USB/Device_Library
    ../USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../USB/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 5.6.0
